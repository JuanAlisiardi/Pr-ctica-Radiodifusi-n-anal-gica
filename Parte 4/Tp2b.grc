options:
  parameters:
    generate_options: qt_gui
    id: Tp2b
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: deltaf
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*np.pi*deltaf)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Usuario\Downloads\fm.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_peak_detector2_fb_0
  id: blocks_peak_detector2_fb
  parameters:
    alpha: '0.001'
    look_ahead: '1000'
    threshold_factor_rise: '7'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_sample_and_hold_xx_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    nconnections: '2'
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_peak_detector2_fb_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_rms_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_sample_and_hold_xx_0, '0']
- [blocks_file_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_peak_detector2_fb_0, '0', blocks_sample_and_hold_xx_0, '1']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_sample_and_hold_xx_0, '0', qtgui_number_sink_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
